## drivers/hwinfo/Kconfig
```kconfig
config CELLON_HWINFO
           tristate "cellon hwinfo Driver"
           default y
           help
           This is the cellon hwinfo driver.
```
